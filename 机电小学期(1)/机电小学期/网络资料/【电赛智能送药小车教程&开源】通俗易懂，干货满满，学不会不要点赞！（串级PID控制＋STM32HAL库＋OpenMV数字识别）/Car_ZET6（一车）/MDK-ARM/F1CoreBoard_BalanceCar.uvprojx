# Keil uVision project F1CoreBoard_BalanceCar.uvprojx, settings and files
target F1CoreBoard_BalanceCar (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF)  CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: F1CoreBoard_BalanceCar +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F103xE
  c include: ../Core/Inc;        ../Drivers/STM32F1xx_HAL_Driver/Inc;        ../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;        ../Drivers/CMSIS/Device/ST/STM32F1xx/Include;        ../Drivers/CMSIS/Include;        ..\user;        ..\user\menu;        ..\user\MPU6050;        ..\user\OLED;        ..\user\bsp_debug;        ..\user\MPU6050\eMPL;        ..\user\Motor;        ..\user\pid;        ..\user\Motor;        ..\user\openmv;        ..\user\openmv;        ..\user\GraySensor;        ..\user\BlueTooth
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f103xe.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c adc.c tim.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group HardWare
    ../user/BlueTooth/: BlueTooth.c
    ../user/bsp_debug/: bsp_debug.c protocol.c
    ../user/GraySensor/: bsp_graySensor.c
    ../user/menu/: bsp_key.c menu.c
    ../user/Motor/: encoder.c
    ../user/OLED/: OLED.c
    ../user/openmv/: openmv.c
    ../user/pid/: bsp_pid.c
    ../user/: bsp_delay.c bsp_led.c control.c
software components: CMSIS:CORE 4.3.0

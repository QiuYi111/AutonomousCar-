# Keil uVision project Agv.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Agv
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD
  c include: ..\inc;..\StdPeriph\inc;..\Libraries\StdPeriph\inc;.\Libraries\StdPeriph\inc;.\CMSIS;..\CMSIS;.\Libraries\CMSIS;..\Libraries\CMSIS
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Source Group 1
    ./: AGVMain.c AGVTimer.c AGVUart1.c AGVComm.c AGVMotor.c AGVBeepLed.c AGVXunJi.c AGVUart3.c AGVConfig.c AGVGenFun.c
    ./Libraries/StdPeriph/src/: stm32f10x_gpio.c stm32f10x_tim.c stm32f10x_rcc.c misc.c stm32f10x_usart.c
    ./Libraries/CMSIS/: core_cm3.c system_stm32f10x.c
    ./Startup/: startup_stm32f10x_hd.s
